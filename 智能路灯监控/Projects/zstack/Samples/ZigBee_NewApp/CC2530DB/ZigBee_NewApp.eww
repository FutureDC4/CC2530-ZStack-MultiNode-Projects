<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ZigBee_NewApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>ZigBee_NewApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>ZigBee_NewApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>ZigBee_NewApp</project>
        <configuration>LightTerminalEB</configuration>
      </member>
      <member>
        <project>ZigBee_NewApp</project>
        <configuration>Light2TerminalEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


